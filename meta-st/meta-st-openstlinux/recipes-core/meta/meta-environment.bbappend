create_sdk_files:append() {

	ln -s environment-setup-${REAL_MULTIMACH_TARGET_SYS} ${SDK_OUTPUT}/${SDKPATH}/environment-setup
}

