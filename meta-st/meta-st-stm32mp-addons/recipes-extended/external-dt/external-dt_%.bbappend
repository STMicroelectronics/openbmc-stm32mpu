# Configure recipe for CubeMX
EXTERNALSRC:stm32mpcommonmx = "${STAGING_EXTDT_DIR}"
EXTERNALSRC_BUILD:stm32mpcommonmx = "${STAGING_EXTDT_DIR}"
